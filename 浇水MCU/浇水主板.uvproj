# Keil uVision project 浇水主板.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C58 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(24000000)
  output: 浇水主板 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: a_comfunc.c a_strfunc.c Delay_12M.c main.c mainioport.c UNIQ_ID.c stc12_adc.c a_timerfunc.c
